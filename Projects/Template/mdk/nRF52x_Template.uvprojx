# Keil uVision project nRF52x_Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nRF52x_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52832_XXAA NRF_SD_BLE_API_VERSION=6 S140 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\components;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_advertising;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_dtm;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_link_ctx_manager;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_racp;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_ancs_c;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_ans_c;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_bas;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_bas_c;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_cscs;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_cts_c;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_dfu;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_dis;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_gls;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_hids;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_hrs;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_hrs_c;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_hts;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_ias;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_ias_c;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_lbs;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_lbs_c;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_lls;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_nus;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_nus_c;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_rscs;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_rscs_c;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\ble_services\ble_tps;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\common;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\nrf_ble_gatt;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\nrf_ble_qwr;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\ble\peer_manager;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\boards;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\atomic;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\atomic_fifo;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\atomic_flags;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\balloc;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\bootloader\ble_dfu;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\bsp;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\button;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\cli;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\crc16;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\crc32;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\crypto;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\csense;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\csense_drv;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\delay;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\ecc;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\experimental_section_vars;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\experimental_task_manager;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\fds;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\fifo;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\fstorage;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\gfx;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\gpiote;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\hardfault;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\hci;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\led_softblink;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\log;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\log\src;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\low_power_pwm;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\mem_manager;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\memobj;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\mpu;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\mutex;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\pwm;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\pwr_mgmt;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\queue;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\ringbuf;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\scheduler;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\sdcard;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\slip;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\sortlist;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\spi_mngr;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\stack_guard;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\strerror;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\svc;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\timer;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\twi_mngr;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\twi_sensor;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\uart;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\usbd;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\usbd\class\audio;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\usbd\class\cdc;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\usbd\class\cdc\acm;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\usbd\class\hid;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\usbd\class\hid\generic;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\usbd\class\hid\kbd;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\usbd\class\hid\mouse;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\usbd\class\msc;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\libraries\util;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\conn_hand_parser;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\conn_hand_parser\ac_rec_parser;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\connection_handover\ac_rec;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\connection_handover\ble_oob_advdata;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\connection_handover\ble_pair_lib;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\connection_handover\ble_pair_msg;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\connection_handover\common;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\connection_handover\ep_oob_rec;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\connection_handover\hs_rec;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\connection_handover\le_oob_rec;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\generic\message;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\generic\record;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\launchapp;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\parser\message;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\parser\record;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\text;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\ndef\uri;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\t2t_lib;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\t2t_parser;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\t4t_lib;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\components\nfc\t4t_parser\apdu;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\t4t_parser\cc_file;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345components\nfc\t4t_parser\hl_detection_procedure;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\components\nfc\t4t_parser\tlv;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\components\softdevice\common;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\components\softdevice\s140\headers;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\components\softdevice\s140\headers\nrf52;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\external\fprintf;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\external\segger_rtt;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\external\utf_converter;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\integration\nrfx;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\integration\nrfx\legacy;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\modules\nrfx;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\modules\nrfx\drivers\include;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\modules\nrfx\hal;E:\Keil\ARM\nRF5_SDK_15.3.0_59ac345\modules\nrfx\mdk
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./: main.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha
